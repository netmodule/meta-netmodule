FILESEXTRAPATHS_prepend := "${THISDIR}/${P}/${MACHINE}:"
